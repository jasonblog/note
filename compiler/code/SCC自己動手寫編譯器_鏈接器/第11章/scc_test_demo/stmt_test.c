/* stmt_test.c源文件 */
/*********************************************************** 
 * 功能:	复合语句，变量作用域测试
 **********************************************************/
void compound_test()
{
	int a = 10;
	
	printf("a=%d\n",a);
	{
		int a = 20;
		printf("a=%d\n",a);
		{
			int a = 30;
			printf("a=%d\n",a);
		}
		printf("a=%d\n",a);
	}	
	printf("a=%d\n",a);
}

/*********************************************************** 
 * 功能:	if语句测试
 **********************************************************/
void if_test()
{
	int a = 3, b = 5;
	
	if(a > b)
		printf("a(%d) > b(%d)\n", a, b);		
	else
		printf("a(%d) < b(%d)\n", a, b);
		
	if(50 > 30)
		printf("50 > 30\n");		
	else
		printf("50 < 30\n");			
}

/*********************************************************** 
 * 功能:	for语句测试,包含continue语句,break语句测试
 **********************************************************/
void for_test()
{
	int i;
	
	for(i = 0; i < 10; i = i + 1)
	{
		if(i == 5)
			continue;
		if(i == 8)
			break;
		printf("i = %d\n",i);
	}
}

/*********************************************************** 
 * 功能:	return语句测试
 **********************************************************/
int return_test()
{
	return 2014;
}

/*********************************************************** 
 * 功能:	main函数
 **********************************************************/
int  main()
{
	compound_test();
	if_test();
	for_test();
	return_test();
		
	return 0;
}

/*********************************************************** 
 * 功能:	入口函数
 **********************************************************/
void  _entry()
{
	int ret;
	ret = main();
	exit(ret);
}