## linux_system/src/TLKH讀書會/03/buildroot/package/helloworld/Config.in
```kconfig
config BR2_PACKAGE_HELLOWORLD
	bool "helloworld"
	default y
	help
			Hello world component.
```
